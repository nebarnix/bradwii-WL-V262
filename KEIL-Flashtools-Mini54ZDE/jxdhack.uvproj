# Keil uVision project jxdhack.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: M054ZAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x03FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: jxdhack
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
